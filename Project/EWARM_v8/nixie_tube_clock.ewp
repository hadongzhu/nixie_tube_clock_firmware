# IAR project nixie_tube_clock.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F100C8 ST STM32F100C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_MD_VL; STM32F100xB; USE_FULL_LL_DRIVER
  ICCARM.CCIncludePath2: ..\..\User\bsp_stm32f100; ..\..\User; ..\..\User\magic_enum; ..\..\Drivers\CMSIS\Include; ..\..\Drivers\STM32F1xx_HAL_Driver\Inc; ..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: nixie_tube_clock.srec
  ILINK.IlinkOutputFile: nixie_tube_clock.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.IccLang: 0
  group bsp
    ../../User/bsp_stm32f100/: bsp.c bsp_DS3231.c bsp_HV57708.c bsp_i2c_gpio.c bsp_key.c bsp_neon_bulb.c bsp_rtc.c bsp_timer.c bsp_ws2812b.c colon.cpp color.cpp control_key.cpp display.cpp factory_test.cpp fifo.c key.cpp led.cpp nixie_tube.cpp theme_pack.cpp tick.cpp time_custom.cpp utils.cpp
  group Device/arm
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/iar/: startup_stm32f100xb.s
  group Drivers/CMSIS
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
  group Drivers/STM32f1xx_LL_Driver
    ../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_ll_adc.c stm32f1xx_ll_crc.c stm32f1xx_ll_dac.c stm32f1xx_ll_dma.c stm32f1xx_ll_exti.c stm32f1xx_ll_fsmc.c stm32f1xx_ll_gpio.c stm32f1xx_ll_i2c.c stm32f1xx_ll_pwr.c stm32f1xx_ll_rcc.c stm32f1xx_ll_rtc.c stm32f1xx_ll_sdmmc.c stm32f1xx_ll_spi.c stm32f1xx_ll_tim.c stm32f1xx_ll_usart.c stm32f1xx_ll_usb.c stm32f1xx_ll_utils.c
  group User
    ../../User/: main.cpp
