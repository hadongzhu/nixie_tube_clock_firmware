# Keil uVision project nixie_tube_clock.uvprojx, settings and files
target nixie_tube_clock (6160000::V6.16::ARMCLANG)
  device: STM32F100C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: nixie_tube_clock +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=8 wLevel=3
  c define: STM32F10X_MD_VL,STM32F100xB,USE_FULL_LL_DRIVER
  c include: ..\..\User\bsp_stm32f100;..\..\User;..\..\Drivers\CMSIS\Include;..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\Drivers\STM32F1xx_HAL_Driver\Inc
  memory RVCT4: ROM 0x8000000 size 0xfc00
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Device/arm
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f100xb.s
  group Drivers/CMSIS
    ../../User/bsp_stm32f100/: system_stm32f1xx.c
  group Drivers/STM32f1xx_LL_Driver
    ../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_ll_adc.c stm32f1xx_ll_crc.c stm32f1xx_ll_dac.c stm32f1xx_ll_dma.c stm32f1xx_ll_exti.c stm32f1xx_ll_gpio.c stm32f1xx_ll_fsmc.c stm32f1xx_ll_i2c.c stm32f1xx_ll_utils.c stm32f1xx_ll_usb.c stm32f1xx_ll_usart.c stm32f1xx_ll_tim.c stm32f1xx_ll_spi.c stm32f1xx_ll_sdmmc.c stm32f1xx_ll_rtc.c stm32f1xx_ll_rcc.c stm32f1xx_ll_pwr.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_tim.c stm32f1xx_hal_dma.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c
  group User
    ../../User/: main.cpp
    ../../User/bsp_stm32f100/: factory_test.cpp
  group BSP
    ../../User/bsp_stm32f100/: bsp.c bsp_DS3231.c bsp_HV57708.c bsp_i2c_gpio.c bsp_iwdg.c bsp_key.c bsp_rtc.c bsp_timer.c bsp_neon_bulb.c bsp_ws2812b.c bsp_internal_flash.c fifo.c colon.cpp led.cpp utils.cpp color.cpp nixie_tube.cpp display.cpp control_key.cpp time_custom.cpp tick.cpp key.cpp theme_pack.cpp storage.cpp
  group Doc
    ../../: readme.md
